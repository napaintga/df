# IAR project FreeRTOS_Basic_cm0plus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BLD53
  ICCARM.CCIncludePath2: ../../../../../../cmsis/include; ../../../../../../devices/psoc6/psoc63/include; ../../../../../../devices/psoc6/ip; ../../../../../../drivers/peripheral
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FreeRTOS_Basic_cm0plus.srec
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --sign "$TARGET_PATH$" --output "$TARGET_PATH$"
  ILINK.IlinkOutputFile: FreeRTOS_Basic_cm0plus.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\devices\psoc6\psoc63\common/iar/linker/cy8c6xx7_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BLD53
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../../../devices/psoc6/psoc63/common/iar/linker/cy8c6xx7_cm0plus.icf
  group common
    ../../../../../../devices/psoc6/psoc63/common/iar/startup/: startup_psoc63_cm0plus.s
    ../../../../../../devices/psoc6/psoc63/common/: system_psoc63_cm0plus.c
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/iar/: cy_syslib_iar.s
  group include
    ../../../../../../devices/psoc6/psoc63/include/: cy_device_headers.h psoc63_config.h system_psoc63.h
  group source
    ../: main.c
