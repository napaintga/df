# Keil uVision project FreeRTOS_Basic_cm0plus.uvprojx, settings and files
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM1(0x10000000,0x100000)IRAM1(0x8000000,0x48000)CPUTYPE("Cortex-M0+") ELITTLE
  output: FreeRTOS_Basic_cm0plus +hex
  AfterMake: ..\..\..\..\..\..\tools\win\elf\cymcuelftool.exe --sign "#L" --output "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BLD53
  c include: ../../../../../../cmsis/include;../../../../../../devices/psoc6/psoc63/include;../../../../../../devices/psoc6/ip;../../../../../../drivers/peripheral;../../../../../../drivers/peripheral
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x28000
  scatter file: ../../../../../../devices/psoc6/psoc63/common/mdk/linker/cy8c6xx7_cm0plus.scat
  group common
    ../../../../../../devices/psoc6/psoc63/common/mdk/startup/: startup_psoc63_cm0plus.s
    ../../../../../../devices/psoc6/psoc63/common/: system_psoc63_cm0plus.c
  group include
    ../../../../../../devices/psoc6/psoc63/include/: cy_device_headers.h psoc63_config.h system_psoc63.h
  group drivers
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
  group source
    ../: main.c
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: FreeRTOS_Basic_cm0plus +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BLD53
  c include: ../../../../../../cmsis/include;../../../../../../devices/psoc6/ip;../../../../../../devices/psoc6/psoc63/include;../../../../../../drivers/peripheral
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x28000
  scatter file: as above
