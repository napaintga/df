<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FreeRTOS_Basic_cm0plus.ewp</path>
  </project>
  <batchBuild/>
</workspace>


