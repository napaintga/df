# IAR project FreeRTOS_Basic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BLD53
  ICCARM.CCIncludePath2: ../../../../../../cmsis/include; ../../../../../../devices/psoc6/psoc63/include; ../../../../../../devices/psoc6/ip; ../../../../../../drivers/peripheral; ../../../../../../rtos/FreeRTOS/10.0.1/Source/include; ../../../../../../rtos/FreeRTOS/10.0.1/Source/portable/IAR/CM4F; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FreeRTOS_Basic.srec
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --merge "$TARGET_PATH$" "../../cm0plus/iar/Debug/Exe/FreeRTOS_Basic_cm0plus.out" --output "$TARGET_PATH$"
  ILINK.IlinkOutputFile: FreeRTOS_Basic.out
  ILINK.IlinkIcfFile: ../../../../../../devices/psoc6/psoc63/common/iar/linker/cy8c6xx7_cm4_dual.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BLD53
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --merge "$TARGET_PATH$" "../../cm0plus/iar/Release/Exe/FreeRTOS_Basic_cm0plus.out" --output "$TARGET_PATH$"
  group common
    ../../../../../../devices/psoc6/psoc63/common/iar/startup/: startup_psoc63_cm4.s
    ../../../../../../devices/psoc6/psoc63/common/: system_psoc63_cm4.c
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/gpio/: cy_gpio.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/iar/: cy_syslib_iar.s
  group FreeRTOS
    ../../../../../../rtos/FreeRTOS/10.0.1/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../rtos/FreeRTOS/10.0.1/Source/portable/MemMang/: heap_1.c
    ../../../../../../rtos/FreeRTOS/10.0.1/Source/portable/IAR/CM4F/: port.c portasm.s
  group include
    ../../../../../../devices/psoc6/psoc63/include/: cy8c6347bzi_bld53.h cy_device_headers.h gpio_psoc63_116_bga_ble.h psoc63_config.h system_psoc63_cm4.h
  group source
    ../: FreeRTOSConfig.h main.c
