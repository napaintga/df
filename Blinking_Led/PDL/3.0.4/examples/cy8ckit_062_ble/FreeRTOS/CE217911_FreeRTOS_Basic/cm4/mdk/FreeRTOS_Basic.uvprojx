# Keil uVision project FreeRTOS_Basic.uvprojx, settings and files
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM1(0x8000000,0x48000)IROM1(0x10000000,0x100000)CPUTYPE("Cortex-M4") FPU2  ELITTLE
  output: FreeRTOS_Basic +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\FreeRTOS_Basic_cm0plus.uvprojx" -t"Release" -j0
  AfterMake: ..\..\..\..\..\..\tools\win\elf\cymcuelftool.exe --merge "#L" "..\..\cm0plus\mdk\output\release\FreeRTOS_Basic_cm0plus.axf" --output "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BLD53
  c include: ..\..\..\..\..\..\cmsis\include;..\..\..\..\..\..\devices\psoc6\psoc63\include;..\..\..\..\..\..\devices\psoc6\ip;..\..\..\..\..\..\drivers\peripheral;..\;..\..\..\..\..\..\rtos\FreeRTOS\10.0.1\Source\portable\mdk\CM4F;..\..\..\..\..\..\rtos\FreeRTOS\10.0.1\Source\include
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x28000
  scatter file: ..\..\..\..\..\..\devices\psoc6\psoc63\common\mdk\linker\cy8c6xx7_cm4_dual.scat
  group common
    ../../../../../../devices/psoc6/psoc63/common/: system_psoc63_cm4.c
    ../../../../../../devices/psoc6/psoc63/common/mdk/startup/: startup_psoc63_cm4.s
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/gpio/: cy_gpio.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
  group FreeRTOS
    ../../../../../../rtos/FreeRTOS/10.0.1/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../rtos/FreeRTOS/10.0.1/Source/portable/MemMang/: heap_1.c
    ../../../../../../rtos/FreeRTOS/10.0.1/Source/portable/MDK/CM4F/: port.c
  group include
    ../../../../../../devices/psoc6/psoc63/include/: cy_device_headers.h system_psoc63.h psoc63_config.h gpio_psoc63_116_bga_ble.h cy8c6347bzi_bld53.h
  group source
    ../: main.c
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: FreeRTOS_Basic +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\FreeRTOS_Basic_cm0plus.uvprojx" -t"Debug" -j0
  AfterMake: ..\..\..\..\..\..\tools\win\elf\cymcuelftool.exe --merge "#L" "..\..\cm0plus\mdk\output\debug\FreeRTOS_Basic_cm0plus.axf" --output "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BLD53
  c include: ..\..\..\..\..\..\cmsis\include;..\..\..\..\..\..\devices\psoc6\ip;..\..\..\..\..\..\devices\psoc6\psoc63\include;..\..\..\..\..\..\drivers\peripheral;..\;..\..\..\..\..\..\rtos\FreeRTOS\10.0.1\Source\include;..\..\..\..\..\..\rtos\FreeRTOS\10.0.1\Source\portable\MDK\CM4F
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x28000
  scatter file: as above
  group left out of the first target's files
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
