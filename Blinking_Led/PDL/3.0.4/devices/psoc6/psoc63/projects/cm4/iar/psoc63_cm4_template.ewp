# IAR project psoc63_cm4_template.ewp, settings and files
configuration CYBLE-416045-02_Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CYBLE_416045_02
  ICCARM.CCIncludePath2: ../../../../../../cmsis/include; ../../../include; ../../../../ip; ../../../../../../drivers/peripheral
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: psoc63_cm4_template.srec
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --merge "$TARGET_PATH$" "../../cm0plus/iar/Debug/Exe/psoc63_cm0plus_template.out" --output "$TARGET_PATH$"
  ILINK.IlinkOutputFile: psoc63_cm4_template.out
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx7_cm4_dual.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CYBLE-416045-02_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CYBLE_416045_02
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --merge "$TARGET_PATH$" "../../cm0plus/iar/Release/Exe/psoc63_cm0plus_template.out" --output "$TARGET_PATH$"
configuration CY8C68237FM-BLE_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C68237FM_BLE
configuration CY8C68237FM-BLE_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C68237FM_BLE
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C68237BZ-BLE_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C68237BZ_BLE
configuration CY8C68237BZ-BLE_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C68237BZ_BLE
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C637FMI-BLD73_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C637FMI_BLD73
configuration CY8C637FMI-BLD73_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C637FMI_BLD73
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C637BZI-MD76_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C637BZI_MD76
configuration CY8C637BZI-MD76_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C637BZI_MD76
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C637BZI-BLD74_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C637BZI_BLD74
configuration CY8C637BZI-BLD74_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C637BZI_BLD74
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347FMI-BLD53_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347FMI_BLD53
configuration CY8C6347FMI-BLD53_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347FMI_BLD53
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347FMI-BLD43_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347FMI_BLD43
configuration CY8C6347FMI-BLD43_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347FMI_BLD43
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347FMI-BLD33_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347FMI_BLD33
configuration CY8C6347FMI-BLD33_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347FMI_BLD33
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347FMI-BLD13_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347FMI_BLD13
configuration CY8C6347FMI-BLD13_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347FMI_BLD13
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BUD53_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BUD53
configuration CY8C6347BZI-BUD53_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BUD53
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BUD43_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BUD43
configuration CY8C6347BZI-BUD43_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BUD43
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BUD33_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BUD33
configuration CY8C6347BZI-BUD33_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BUD33
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BLD54_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BLD54
configuration CY8C6347BZI-BLD54_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BLD54
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BLD53_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BLD53
configuration CY8C6347BZI-BLD53_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BLD53
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BLD44_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BLD44
configuration CY8C6347BZI-BLD44_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BLD44
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BLD43_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BLD43
configuration CY8C6347BZI-BLD43_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BLD43
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BLD34_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BLD34
configuration CY8C6347BZI-BLD34_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BLD34
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6347BZI-BLD33_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6347BZI_BLD33
configuration CY8C6347BZI-BLD33_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6347BZI_BLD33
  ICCARM.CCOptLevel: 3
  postbuild: as above
configuration CY8C6337BZI-BLF13_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6337BZI_BLF13
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --sign "$TARGET_PATH$" --output "$TARGET_PATH$"
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx7_cm4.icf
configuration CY8C6337BZI-BLF13_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6337BZI_BLF13
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx7_cm4.icf
configuration CY8C6336BZI-BUD13_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6336BZI_BUD13
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4_dual.icf
configuration CY8C6336BZI-BUD13_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6336BZI_BUD13
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4_dual.icf
configuration CY8C6336BZI-BLF04_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6336BZI_BLF04
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6336BZI-BLF04_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6336BZI_BLF04
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6336BZI-BLF03_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6336BZI_BLF03
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6336BZI-BLF03_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6336BZI_BLF03
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6336BZI-BLD14_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6336BZI_BLD14
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4_dual.icf
configuration CY8C6336BZI-BLD14_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6336BZI_BLD14
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4_dual.icf
configuration CY8C6336BZI-BLD13_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6336BZI_BLD13
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4_dual.icf
configuration CY8C6336BZI-BLD13_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6336BZI_BLD13
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4_dual.icf
configuration CY8C6316BZI-BLF54_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6316BZI_BLF54
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6316BZI-BLF54_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6316BZI_BLF54
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6316BZI-BLF53_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6316BZI_BLF53
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6316BZI-BLF53_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6316BZI_BLF53
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6316BZI-BLF04_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6316BZI_BLF04
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6316BZI-BLF04_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6316BZI_BLF04
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6316BZI-BLF03_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6316BZI_BLF03
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6316BZI-BLF03_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6316BZI_BLF03
  ICCARM.CCOptLevel: 3
  postbuild: as above
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
  group common
    ../../../common/iar/startup/: startup_psoc63_cm4.s
    ../../../common/: system_psoc63_cm4.c
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/iar/: cy_syslib_iar.s
  group include
    ../../../include/: cy_device_headers.h psoc63_config.h system_psoc63.h
  group source
    ../: main.c
