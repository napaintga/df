# Keil uVision project psoc63_cm0plus_template.uvprojx, settings and files
target CY8C6336BZI-BLD13_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM1(0x10000000,0x80000)IRAM1(0x8000000,0x20000)CPUTYPE("Cortex-M0+") ELITTLE
  output: psoc63_cm0plus_template +hex
  AfterMake: ..\..\..\..\..\..\tools\win\elf\cymcuelftool.exe --sign "#L" --output "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6336BZI_BLD13
  c include: ../../../../../../cmsis/include;../../../include;../../../../ip;../../../../../../drivers/peripheral
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm0plus.scat
  group common
    ../../../common/mdk/startup/: startup_psoc63_cm0plus.s
    ../../../common/: system_psoc63_cm0plus.c
  group include
    ../../../include/: cy_device_headers.h psoc63_config.h system_psoc63.h
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
  group source
    ../: main.c
target CY8C6336BZI-BLD13_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6336BZI_BLD13
  c include: ../../../../../../cmsis/include;../../../../ip;../../../include;../../../../../../drivers/peripheral
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm0plus.scat
target CY8C6336BZI-BLD14_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6336BZI_BLD14
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm0plus.scat
target CY8C6336BZI-BLD14_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6336BZI_BLD14
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm0plus.scat
target CY8C6336BZI-BUD13_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6336BZI_BUD13
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm0plus.scat
target CY8C6336BZI-BUD13_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6336BZI_BUD13
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm0plus.scat
target CY8C6347BZI-BLD33_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM1(0x10000000,0x100000)IRAM1(0x8000000,0x48000)CPUTYPE("Cortex-M0+") ELITTLE
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BLD33
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD33_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BLD33
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD34_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BLD34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD34_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BLD34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD43_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BLD43
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD43_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BLD43
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD44_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BLD44
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD44_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BLD44
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD53_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BLD53
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD53_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BLD53
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD54_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BLD54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BLD54_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BLD54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BUD33_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BUD33
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BUD33_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BUD33
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BUD43_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BUD43
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BUD43_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BUD43
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BUD53_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347BZI_BUD53
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347BZI-BUD53_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347BZI_BUD53
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347FMI-BLD13_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347FMI_BLD13
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347FMI-BLD13_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347FMI_BLD13
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347FMI-BLD33_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347FMI_BLD33
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347FMI-BLD33_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347FMI_BLD33
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347FMI-BLD43_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347FMI_BLD43
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347FMI-BLD43_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347FMI_BLD43
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347FMI-BLD53_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6347FMI_BLD53
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C6347FMI-BLD53_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6347FMI_BLD53
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C637BZI-BLD74_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C637BZI_BLD74
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C637BZI-BLD74_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C637BZI_BLD74
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C637BZI-MD76_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C637BZI_MD76
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C637BZI-MD76_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C637BZI_MD76
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C637FMI-BLD73_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C637FMI_BLD73
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C637FMI-BLD73_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C637FMI_BLD73
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C68237BZ-BLE_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C68237BZ_BLE
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C68237BZ-BLE_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C68237BZ_BLE
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C68237FM-BLE_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C68237FM_BLE
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CY8C68237FM-BLE_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C68237FM_BLE
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CYBLE-416045-02_Release (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CYBLE_416045_02
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
target CYBLE-416045-02_Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc63_cm0plus_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CYBLE_416045_02
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm0plus.scat
