<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\psoc62_cm4_template.ewp</path>
  </project>
  <batchBuild/>
</workspace>


