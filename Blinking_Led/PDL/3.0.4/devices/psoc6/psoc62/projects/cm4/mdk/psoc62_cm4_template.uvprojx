# Keil uVision project psoc62_cm4_template.uvprojx, settings and files
target CY8C6246BZI-D04_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM1(0x10000000,0x80000)IRAM1(0x8000000,0x20000)CPUTYPE("Cortex-M4") FPU2  ELITTLE
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6246BZI-D04_Release" -j0
  AfterMake: ..\..\..\..\..\..\tools\win\elf\cymcuelftool.exe --merge "#L" "..\..\cm0plus\mdk\output\release\psoc62_cm0plus_template.axf" --output "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6246BZI_D04
  c include: ../../../../../../cmsis/include;../../../include;../../../../ip;../../../../../../drivers/peripheral
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4_dual.scat
  group common
    ../../../common/mdk/startup/: startup_psoc62_cm4.s
    ../../../common/: system_psoc62_cm4.c
  group include
    ../../../include/: cy_device_headers.h psoc62_config.h system_psoc62.h
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
  group source
    ../: main.c
target CY8C6246BZI-D04_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6246BZI-D04_Debug" -j0
  AfterMake: ..\..\..\..\..\..\tools\win\elf\cymcuelftool.exe --merge "#L" "..\..\cm0plus\mdk\output\debug\psoc62_cm0plus_template.axf" --output "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6246BZI_D04
  c include: ../../../../../../cmsis/include;../../../../ip;../../../include;../../../../../../drivers/peripheral
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4_dual.scat
target CY8C6247BFI-D54_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM1(0x10000000,0x100000)IRAM1(0x8000000,0x48000)CPUTYPE("Cortex-M4") FPU2  ELITTLE
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BFI-D54_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247BFI_D54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BFI-D54_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BFI-D54_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247BFI_D54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BZI-AUD54_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BZI-AUD54_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247BZI_AUD54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BZI-AUD54_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BZI-AUD54_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247BZI_AUD54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BZI-D34_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BZI-D34_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247BZI_D34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BZI-D34_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BZI-D34_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247BZI_D34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BZI-D44_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BZI-D44_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247BZI_D44
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BZI-D44_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BZI-D44_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247BZI_D44
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BZI-D54_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BZI-D54_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247BZI_D54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247BZI-D54_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247BZI-D54_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247BZI_D54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247FDI-D02_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247FDI-D02_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247FDI_D02
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247FDI-D02_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247FDI-D02_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247FDI_D02
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247FDI-D32_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247FDI-D32_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247FDI_D32
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247FDI-D32_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247FDI-D32_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247FDI_D32
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247FDI-D52_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247FDI-D52_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247FDI_D52
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247FDI-D52_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247FDI-D52_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247FDI_D52
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247FTI-D52_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247FTI-D52_Release" -j0
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6247FTI_D52
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
target CY8C6247FTI-D52_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc62_cm4_template +hex
  AfterMake: UV4 -b "..\..\cm0plus\mdk\psoc62_cm0plus_template.uvprojx" -t"CY8C6247FTI-D52_Debug" -j0
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6247FTI_D52
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4_dual.scat
