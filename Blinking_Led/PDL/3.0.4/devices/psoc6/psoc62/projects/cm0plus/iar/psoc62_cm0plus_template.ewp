# IAR project psoc62_cm0plus_template.ewp, settings and files
configuration CY8C6247FTI-D52_Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CY8C6247FTI_D52
  ICCARM.CCIncludePath2: ../../../../../../cmsis/include; ../../../include; ../../../../ip; ../../../../../../drivers/peripheral
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: psoc62_cm0plus_template.srec
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --sign "$TARGET_PATH$" --output "$TARGET_PATH$"
  ILINK.IlinkOutputFile: psoc62_cm0plus_template.out
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx7_cm0plus.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CY8C6247FTI-D52_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247FTI_D52
  ICCARM.CCOptLevel: 3
configuration CY8C6247FDI-D52_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6247FDI_D52
configuration CY8C6247FDI-D52_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247FDI_D52
  ICCARM.CCOptLevel: 3
configuration CY8C6247FDI-D32_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6247FDI_D32
configuration CY8C6247FDI-D32_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247FDI_D32
  ICCARM.CCOptLevel: 3
configuration CY8C6247FDI-D02_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6247FDI_D02
configuration CY8C6247FDI-D02_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247FDI_D02
  ICCARM.CCOptLevel: 3
configuration CY8C6247BZI-D54_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6247BZI_D54
configuration CY8C6247BZI-D54_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247BZI_D54
  ICCARM.CCOptLevel: 3
configuration CY8C6247BZI-D44_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6247BZI_D44
configuration CY8C6247BZI-D44_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247BZI_D44
  ICCARM.CCOptLevel: 3
configuration CY8C6247BZI-D34_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6247BZI_D34
configuration CY8C6247BZI-D34_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247BZI_D34
  ICCARM.CCOptLevel: 3
configuration CY8C6247BZI-AUD54_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6247BZI_AUD54
configuration CY8C6247BZI-AUD54_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247BZI_AUD54
  ICCARM.CCOptLevel: 3
configuration CY8C6247BFI-D54_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6247BFI_D54
configuration CY8C6247BFI-D54_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6247BFI_D54
  ICCARM.CCOptLevel: 3
configuration CY8C6246BZI-D04_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6246BZI_D04
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm0plus.icf
configuration CY8C6246BZI-D04_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6246BZI_D04
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm0plus.icf
  group common
    ../../../common/iar/startup/: startup_psoc62_cm0plus.s
    ../../../common/: system_psoc62_cm0plus.c
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/iar/: cy_syslib_iar.s
  group include
    ../../../include/: cy_device_headers.h psoc62_config.h system_psoc62.h
  group source
    ../: main.c
