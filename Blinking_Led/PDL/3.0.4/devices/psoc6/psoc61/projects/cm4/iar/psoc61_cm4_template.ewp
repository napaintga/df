# IAR project psoc61_cm4_template.ewp, settings and files
configuration CY8C6137FDI-F02_Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CY8C6137FDI_F02
  ICCARM.CCIncludePath2: ../../../../../../cmsis/include; ../../../include; ../../../../ip; ../../../../../../drivers/peripheral
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: psoc61_cm4_template.srec
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --sign "$TARGET_PATH$" --output "$TARGET_PATH$"
  ILINK.IlinkOutputFile: psoc61_cm4_template.out
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx7_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CY8C6137FDI-F02_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6137FDI_F02
  ICCARM.CCOptLevel: 3
configuration CY8C6137BZI-F54_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6137BZI_F54
configuration CY8C6137BZI-F54_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6137BZI_F54
  ICCARM.CCOptLevel: 3
configuration CY8C6137BZI-F34_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6137BZI_F34
configuration CY8C6137BZI-F34_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6137BZI_F34
  ICCARM.CCOptLevel: 3
configuration CY8C6137BZI-F14_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6137BZI_F14
configuration CY8C6137BZI-F14_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6137BZI_F14
  ICCARM.CCOptLevel: 3
configuration CY8C6136FTI-F42_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6136FTI_F42
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6136FTI-F42_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6136FTI_F42
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6136FDI-F42_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6136FDI_F42
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6136FDI-F42_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6136FDI_F42
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6136BZI-F34_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6136BZI_F34
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6136BZI-F34_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6136BZI_F34
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6136BZI-F14_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6136BZI_F14
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6136BZI-F14_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6136BZI_F14
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6117FDI-F02_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6117FDI_F02
configuration CY8C6117FDI-F02_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6117FDI_F02
  ICCARM.CCOptLevel: 3
configuration CY8C6117BZI-F34_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6117BZI_F34
configuration CY8C6117BZI-F34_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6117BZI_F34
  ICCARM.CCOptLevel: 3
configuration CY8C6116BZI-F54_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6116BZI_F54
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
configuration CY8C6116BZI-F54_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6116BZI_F54
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
  group common
    ../../../common/iar/startup/: startup_psoc61_cm4.s
    ../../../common/: system_psoc61_cm4.c
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/iar/: cy_syslib_iar.s
  group include
    ../../../include/: cy_device_headers.h psoc61_config.h system_psoc61.h
  group source
    ../: main.c
