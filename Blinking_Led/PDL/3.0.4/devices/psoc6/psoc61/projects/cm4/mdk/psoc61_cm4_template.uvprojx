# Keil uVision project psoc61_cm4_template.uvprojx, settings and files
target CY8C6116BZI-F54_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM1(0x10000000,0x80000)IRAM1(0x8000000,0x20000)CPUTYPE("Cortex-M4") FPU2  ELITTLE
  output: psoc61_cm4_template +hex
  AfterMake: ..\..\..\..\..\..\tools\win\elf\cymcuelftool.exe --sign "#L" --output "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6116BZI_F54
  c include: ../../../../../../cmsis/include;../../../include;../../../../ip;../../../../../../drivers/peripheral
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
  group common
    ../../../common/mdk/startup/: startup_psoc61_cm4.s
    ../../../common/: system_psoc61_cm4.c
  group include
    ../../../include/: cy_device_headers.h psoc61_config.h system_psoc61.h
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/mdk/: cy_syslib_mdk.s
  group source
    ../: main.c
target CY8C6116BZI-F54_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6116BZI_F54
  c include: ../../../../../../cmsis/include;../../../../ip;../../../include;../../../../../../drivers/peripheral
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6117BZI-F34_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM1(0x10000000,0x100000)IRAM1(0x8000000,0x48000)CPUTYPE("Cortex-M4") FPU2  ELITTLE
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6117BZI_F34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6117BZI-F34_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6117BZI_F34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6117FDI-F02_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6117FDI_F02
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6117FDI-F02_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6117FDI_F02
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6136BZI-F14_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6136BZI_F14
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6136BZI-F14_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6136BZI_F14
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6136BZI-F34_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6136BZI_F34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6136BZI-F34_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6136BZI_F34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6136FDI-F42_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6136FDI_F42
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6136FDI-F42_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6136FDI_F42
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6136FTI-F42_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6136FTI_F42
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6136FTI-F42_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6136FTI_F42
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx6_cm4.scat
target CY8C6137BZI-F14_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6137BZI_F14
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6137BZI-F14_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6137BZI_F14
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6137BZI-F34_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6137BZI_F34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6137BZI-F34_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6137BZI_F34
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6137BZI-F54_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6137BZI_F54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6137BZI-F54_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6137BZI_F54
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6137FDI-F02_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG CY8C6137FDI_F02
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
target CY8C6137FDI-F02_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: psoc61_cm4_template +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG CY8C6137FDI_F02
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: ../../../common/mdk/linker/cy8c6xx7_cm4.scat
