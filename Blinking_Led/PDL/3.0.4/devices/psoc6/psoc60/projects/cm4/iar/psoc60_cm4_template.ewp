# IAR project psoc60_cm4_template.ewp, settings and files
configuration CY8C6036BZI-F04_Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CY8C6036BZI_F04
  ICCARM.CCIncludePath2: ../../../../../../cmsis/include; ../../../include; ../../../../ip; ../../../../../../drivers/peripheral
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: psoc60_cm4_template.srec
  postbuild: "../../../../../../tools/win/elf/cymcuelftool.exe" --sign "$TARGET_PATH$" --output "$TARGET_PATH$"
  ILINK.IlinkOutputFile: psoc60_cm4_template.out
  ILINK.IlinkIcfFile: ../../../common/iar/linker/cy8c6xx6_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CY8C6036BZI-F04_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6036BZI_F04
  ICCARM.CCOptLevel: 3
configuration CY8C6016BZI-F04_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CY8C6016BZI_F04
configuration CY8C6016BZI-F04_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CY8C6016BZI_F04
  ICCARM.CCOptLevel: 3
  group common
    ../../../common/iar/startup/: startup_psoc60_cm4.s
    ../../../common/: system_psoc60_cm4.c
  group drivers
    ../../../../../../drivers/peripheral/flash/: cy_flash.c
    ../../../../../../drivers/peripheral/ipc/: cy_ipc_config.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../../../../../../drivers/peripheral/sysint/: cy_sysint.c
    ../../../../../../drivers/peripheral/syslib/: cy_syslib.c
    ../../../../../../drivers/peripheral/syslib/iar/: cy_syslib_iar.s
  group include
    ../../../include/: cy_device_headers.h psoc60_config.h system_psoc60.h
  group source
    ../: main.c
